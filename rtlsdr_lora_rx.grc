options:
  parameters:
    author: Tom Nguyen
    generate_options: qt_gui
    id: rtlsdr_lora_rx
    output_language: python
    title: RTL-SDR LoRa-Rx
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: cc
  states: {}
- name: lora_rx_0
  id: lora_rx
  parameters:
    bw: '125000'
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '12'
    print_rx: '[False,True]'
    samp_rate: '250000'
    sf: '10'
    soft_decoding: 'True'
    sync_word: '[0x12]'
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: 865.1e6
    gain: '49'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [dc_blocker_xx_0, '0', lora_rx_0, '0']
- [soapy_rtlsdr_source_0, '0', dc_blocker_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
